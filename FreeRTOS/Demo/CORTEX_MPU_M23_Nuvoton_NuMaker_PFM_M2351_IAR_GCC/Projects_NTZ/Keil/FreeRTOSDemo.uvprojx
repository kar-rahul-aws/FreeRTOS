# Keil uVision project FreeRTOSDemo.uvprojx, settings and files
target FreeRTOSDemo (6190000::V6.19::ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.20
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT = UART0
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: .\Config;..\Keil;..\..\RegTests;..\..\Nuvoton_Code\StdDriver\inc;..\..\Nuvoton_Code\CMSIS\Include;..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include;..\..\..\..\Source\include;..\..\..\..\Source\portable\GCC\ARM_CM23_NTZ\non_secure;..\..\..\Common\ARMv8M\mpu_demo;..\..\..\Common\ARMv8M\reg_tests\GCC\ARM_CM23\non_secure;..\..\..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\FreeRTOSDemo.sct
  group Config
    ./Config/: FreeRTOSConfig.h
  group Device
    ../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../Nuvoton_Code/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group Drivers
    ../../Nuvoton_Code/StdDriver/src/: clk.c gpio.c retarget.c
  group FreeRTOS
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c portasm.h portmacro.h portmacrocommon.h
    ../../../../Source/portable/MemMang/: heap_4.c
    ../../../../Source/portable/Common/: mpu_wrappers.c
  group Demo
    ../../../Common/ARMv8M/mpu_demo/: mpu_demo.c
    ../../../Common/ARMv8M/reg_tests/GCC/ARM_CM23/non_secure/: reg_test_asm.c
    ../../../Common/ARMv8M/soak_tests/: AbortDelay.c BlockQ.c blocktim.c countsem.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntQueue.c IntQueueTimer.c IntSemTest.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TestRunner.c TimerDemo.c
  group User
    ./: main.c
    ../../RegTests/: reg_tests.c reg_tests.h
