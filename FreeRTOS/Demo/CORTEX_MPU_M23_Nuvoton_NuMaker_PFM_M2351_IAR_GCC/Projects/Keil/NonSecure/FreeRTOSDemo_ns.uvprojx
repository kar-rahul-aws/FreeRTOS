# Keil uVision project FreeRTOSDemo_ns.uvprojx, settings and files
target FreeRTOSDemo_ns (6190000::V6.19::ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.20
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo_ns +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT=UART0_NS
  c include: ..\Config;..\..\..\..\Common\ARMv8M\tz_demo;..\..\..\..\Common\ARMv8M\mpu_demo;..\..\..\..\..\Source\include;..\..\..\..\..\Source\portable\GCC\ARM_CM23\secure;..\..\..\..\..\Source\portable\GCC\ARM_CM23\non_secure;..\..\..\Nuvoton_Code\StdDriver\inc;..\..\..\Nuvoton_Code\CMSIS\Include;..\..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include;..\..\..\..\..\Demo\Common\include;..\..\..\..\Common\ARMv8M\soak_tests;..\..\..\RegTests;..\..\..\..\..\Demo\Common\ARMv8M\reg_tests\GCC\ARM_CM23\non_secure;..\..\..\..\..\Demo\Common\ARMv8M\reg_tests\GCC\ARM_CM23\secure
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: FreeRTOSDemo_ns.sct
  group Config
    ../Config/: FreeRTOSConfig.h
  group Device
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group Drivers
    ../Secure/Objects/: FreeRTOSDemo_importlib.o
    ../../../Nuvoton_Code/StdDriver/src/: gpio.c retarget.c clk.c
  group FreeRTOS
    ../../../../../Source/: event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../../../../Source/portable/MemMang/: heap_4.c
    ../../../../../Source/portable/GCC/ARM_CM23/non_secure/: port.c portasm.c portasm.h portmacro.h
    ../../../../../Source/portable/Common/: mpu_wrappers.c
  group Demos
    ../../../../Common/ARMv8M/mpu_demo/: mpu_demo.c
    ../../../../Common/ARMv8M/tz_demo/: tz_demo.c
    ../../../../CORTEX_MPU_M3_NUCLEO_L152RE_GCC/Demo/: AbortDelay.c BlockQ.c blocktim.c countsem.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntQueue.c IntQueueTimer.c IntSemTest.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TestRunner.c TimerDemo.c
    ../../../RegTests/: reg_tests.c
    ../../../../Common/ARMv8M/reg_tests/GCC/ARM_CM23/non_secure/: reg_test_asm.c
  group User
    ./: main_ns.c
