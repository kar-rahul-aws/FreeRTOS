# IAR project FreeRTOSDemo.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; MCUXPRESSO_SDK; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: Config; ..\..\NXP_Code\board; ..\..\NXP_Code\CMSIS; ..\..\NXP_Code\component\lists; ..\..\NXP_Code\component\uart; ..\..\NXP_Code\device; ..\..\NXP_Code\drivers; ..\..\NXP_Code\utilities; ..\..\..\..\Source\include; ..\..\..\..\Source\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\Common\ARMv8M\mpu_demo; ..\..\..\Common\ARMv8M\reg_tests\IAR\ARM_CM33\non_secure; ..\..\RegTests; ..\..\..\Common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: Config
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.bin
  ILINK.IlinkOutputFile: FreeRTOSDemo.out
  ILINK.IlinkIcfFile: FreeRTOSDemo_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Config
    Config/: FreeRTOSConfig.h
  group Demos
    ../../../Common/ARMv8M/soak_tests/: AbortDelay.c BlockQ.c blocktim.c countsem.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntQueue.c IntQueueTimer.c IntSemTest.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TestRunner.c TimerDemo.c
  group Demos/mpu_demo
    ../../../Common/ARMv8M/mpu_demo/: mpu_demo.c mpu_demo.h
  group Demos/reg_tests
    ../../../Common/ARMv8M/reg_tests/IAR/ARM_CM33/non_secure/: reg_test_asm.h reg_test_asm.s
  group FreeRTOS
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Common
    ../../../../Source/portable/Common/: mpu_wrappers.c
  group FreeRTOS/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS/portable/IAR/ARM_CM33_NTZ
    ../../../../Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group NXP_Code/board
    ../../NXP_Code/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group NXP_Code/CMSIS
    ../../NXP_Code/CMSIS/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group NXP_Code/component/lists
    ../../NXP_Code/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group NXP_Code/component/uart
    ../../NXP_Code/component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group NXP_Code/device
    ../../NXP_Code/device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group NXP_Code/drivers
    ../../NXP_Code/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group NXP_Code/startup
    ../../NXP_Code/startup/: startup_LPC55S69_cm33_core0.s
  group NXP_Code/utilities
    ../../NXP_Code/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
  group RegTests
    ../../RegTests/: reg_tests.c reg_tests.h
  group User
    ./: fault_handler.s
    ../../User/NTZ/: main.c
