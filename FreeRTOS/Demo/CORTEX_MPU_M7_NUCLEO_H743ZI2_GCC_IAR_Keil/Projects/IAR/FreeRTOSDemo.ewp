# IAR project FreeRTOSDemo.ewp, settings and files
configuration FreeRTOSDemo (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\..\ST_Code\Core\Inc; ..\..\ST_Code\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\ST_Code\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; ..\..\ST_Code\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\ST_Code\Drivers\CMSIS\Include; ..\..\..\..\Source\include; ..\..\..\..\Source\portable\IAR\ARM_CM4F_MPU; ..\..\Config; ..\..\Demo; ..\..\..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\ST_Code\Core\Inc; ..\..\Config
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.hex
  ILINK.IlinkOutputFile: FreeRTOSDemo.out
  ILINK.IlinkIcfFile: stm32h743xx_flash_dtcram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    ../../Config/: FreeRTOSConfig.h
  group Demo
    ../../Demo/: AbortDelay.c AbortDelay.h app_main.c app_main.h BlockQ.c BlockQ.h blocktim.c countsem.c dynamic.c EventGroupsDemo.c EventGroupsDemo.h flop.c GenQTest.c GenQTest.h integer.c IntQueue.c IntQueue.h IntQueueTimer.c IntQueueTimer.h IntSemTest.c MessageBufferDemo.c mpu_demo.c mpu_demo.h PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TestRunner.c TestRunner.h TimerDemo.c
  group FreeRTOS
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../../../Source/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable/Common
    ../../../../Source/portable/Common/: mpu_wrappers_v2.c
  group FreeRTOS/portable/IAR/ARM_CM4F_MPU
    ../../../../Source/portable/IAR/ARM_CM4F_MPU/: mpu_wrappers_v2_asm.S port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group ST_Code/Core/Inc
    ../../ST_Code/Core/Inc/: main.h stm32h7xx_hal_conf.h stm32h7xx_it.h
  group ST_Code/Core/Src
    ../../ST_Code/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c system_stm32h7xx.c
  group ST_Code/Drivers/STM32H7xx_HAL_Driver/Inc
    ../../ST_Code/Drivers/STM32H7xx_HAL_Driver/Inc/: stm32_assert_template.h stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cec.h stm32h7xx_hal_comp.h stm32h7xx_hal_conf_template.h stm32h7xx_hal_cortex.h stm32h7xx_hal_crc.h stm32h7xx_hal_crc_ex.h stm32h7xx_hal_cryp.h stm32h7xx_hal_cryp_ex.h stm32h7xx_hal_dac.h stm32h7xx_hal_dac_ex.h stm32h7xx_hal_dcmi.h stm32h7xx_hal_def.h stm32h7xx_hal_dfsdm.h stm32h7xx_hal_dfsdm_ex.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma2d.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_dsi.h stm32h7xx_hal_dts.h stm32h7xx_hal_eth.h stm32h7xx_hal_eth_ex.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gfxmmu.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hash.h stm32h7xx_hal_hash_ex.h stm32h7xx_hal_hcd.h stm32h7xx_hal_hrtim.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_i2s.h stm32h7xx_hal_i2s_ex.h stm32h7xx_hal_irda.h stm32h7xx_hal_irda_ex.h stm32h7xx_hal_iwdg.h stm32h7xx_hal_jpeg.h stm32h7xx_hal_lptim.h stm32h7xx_hal_ltdc.h stm32h7xx_hal_ltdc_ex.h stm32h7xx_hal_mdios.h stm32h7xx_hal_mdma.h stm32h7xx_hal_mmc.h stm32h7xx_hal_mmc_ex.h stm32h7xx_hal_nand.h stm32h7xx_hal_nor.h stm32h7xx_hal_opamp.h stm32h7xx_hal_opamp_ex.h stm32h7xx_hal_ospi.h stm32h7xx_hal_otfdec.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pssi.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_qspi.h stm32h7xx_hal_ramecc.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_rng.h stm32h7xx_hal_rng_ex.h stm32h7xx_hal_rtc.h stm32h7xx_hal_rtc_ex.h stm32h7xx_hal_sai.h stm32h7xx_hal_sai_ex.h stm32h7xx_hal_sd.h stm32h7xx_hal_sd_ex.h stm32h7xx_hal_sdram.h stm32h7xx_hal_smartcard.h stm32h7xx_hal_smartcard_ex.h stm32h7xx_hal_smbus.h stm32h7xx_hal_spdifrx.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_sram.h stm32h7xx_hal_swpmi.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_hal_usart.h stm32h7xx_hal_usart_ex.h stm32h7xx_hal_wwdg.h stm32h7xx_ll_adc.h stm32h7xx_ll_bdma.h stm32h7xx_ll_bus.h stm32h7xx_ll_comp.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crc.h stm32h7xx_ll_crs.h stm32h7xx_ll_dac.h stm32h7xx_ll_delayblock.h stm32h7xx_ll_dma.h stm32h7xx_ll_dma2d.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_fmc.h stm32h7xx_ll_gpio.h stm32h7xx_ll_hrtim.h stm32h7xx_ll_hsem.h stm32h7xx_ll_i2c.h stm32h7xx_ll_iwdg.h stm32h7xx_ll_lptim.h stm32h7xx_ll_lpuart.h stm32h7xx_ll_mdma.h stm32h7xx_ll_opamp.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_rng.h stm32h7xx_ll_rtc.h stm32h7xx_ll_sdmmc.h stm32h7xx_ll_spi.h stm32h7xx_ll_swpmi.h stm32h7xx_ll_system.h stm32h7xx_ll_tim.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_utils.h stm32h7xx_ll_wwdg.h
  group ST_Code/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy
    ../../ST_Code/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group ST_Code/Drivers/STM32H7xx_HAL_Driver/Src
    ../../ST_Code/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c
  group Startup
    ./: memfault_handler.s startup_stm32h743xx.s
